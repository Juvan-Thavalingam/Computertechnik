# Keil uVision project CT_Board_Periphery_Test.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.4
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CT_Board_Periphery_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: init_ctboard.c main.c scheduler.c tests.c utils_ctboard.c
software components: Device:Startup 4.0.4, HAL:ADC 4.0.4, HAL:FMC 4.0.4, HAL:GPIO 4.0.4, HAL:PWR 4.0.4, HAL:RCC 4.0.4, HAL:SYSTICK 4.0.4
